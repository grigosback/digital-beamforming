options:
  parameters:
    author: grigosback
    generate_options: qt_gui
    id: doaesprit_test
    output_language: python
    title: DoA Esprit Estimation - Test
  states: {}

blocks:
- name: phi
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Azimut Angle
    orient: Qt.Horizontal
    start: '-180'
    step: '1'
    stop: '180'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: theta
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Elevation Angle
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '90'
    value: '45'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: short
  states: {}
- name: beamforming_doaesprit_py_cf_0
  id: beamforming_doaesprit_py_cf
  parameters:
    decimation: '128'
    fc: fc
    mx: mx
    my: my
    n: n
  states: {}
- name: beamforming_phasedarray_py_cc_0
  id: beamforming_phasedarray_py_cc
  parameters:
    fc: fc
    mx: mx
    my: my
    phi: phi
    theta: theta
  states: {}
- name: beamforming_randomsampler_py_cc_0_0
  id: beamforming_randomsampler_py_cc
  parameters:
    decimation: '8'
    vlen: mx*my
  states: {}
- name: blocks_short_to_char_0
  id: blocks_short_to_char
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
    vlen: mx*my
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '16'
  states: {}
- name: fc
  id: parameter
  parameters:
    label: Carrier frequency
    type: eng_float
    value: 436e6
  states: {}
- name: mx
  id: parameter
  parameters:
    label: '# elements in x'
    type: intx
    value: '4'
  states: {}
- name: my
  id: parameter
  parameters:
    label: '# elements in y'
    type: intx
    value: '4'
  states: {}
- name: n
  id: parameter
  parameters:
    label: '# impinging signals'
    type: intx
    value: '1'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 1,0,1,1
    max: '90'
    min: '0'
    name: '"Elevation"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 3,0,1,1
    max: '180'
    min: '-180'
    name: Azimut
    type: float
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_short_to_char_0, '0']
- [beamforming_doaesprit_py_cf_0, '0', qtgui_number_sink_0, '0']
- [beamforming_doaesprit_py_cf_0, '1', qtgui_number_sink_0_0, '0']
- [beamforming_phasedarray_py_cc_0, '0', blocks_throttle_0, '0']
- [beamforming_randomsampler_py_cc_0_0, '0', beamforming_doaesprit_py_cf_0, '0']
- [blocks_short_to_char_0, '0', digital_gmsk_mod_0, '0']
- [blocks_throttle_0, '0', beamforming_randomsampler_py_cc_0_0, '0']
- [digital_gmsk_mod_0, '0', beamforming_phasedarray_py_cc_0, '0']

metadata:
  file_format: 1
