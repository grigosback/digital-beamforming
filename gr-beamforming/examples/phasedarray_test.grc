options:
  parameters:
    author: grigosback
    generate_options: qt_gui
    id: phasedarray_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: beamforming_phasedarray_py_cc_0
  id: beamforming_phasedarray_py_cc
  parameters:
    fc: 436e6
    mx: '4'
    my: '4'
    phi: '60'
    theta: '30'
  states: {}
- name: blocks_vector_sink_x_0
  id: blocks_vector_sink_x
  parameters:
    type: complex
    vlen: '16'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: complex
    vector: range(10)
  states: {}

connections:
- [beamforming_phasedarray_py_cc_0, '0', blocks_vector_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', beamforming_phasedarray_py_cc_0, '0']

metadata:
  file_format: 1
