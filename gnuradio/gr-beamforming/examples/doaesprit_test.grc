options:
  parameters:
    author: grigosback
    generate_options: qt_gui
    id: doaesprit_test
    output_language: python
    title: DoA Esprit Estimation - Test
  states: {}

blocks:
- name: bps
  id: variable
  parameters:
    value: const.bits_per_symbol()
  states: {}
- name: const
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    label: Noise Voltage
    orient: Qt.Horizontal
    start: '0'
    step: '0.001'
    stop: '10'
    value: '0'
  states: {}
- name: phi
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Azimut Angle
    orient: Qt.Horizontal
    start: '-180'
    step: '1'
    stop: '180'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: theta
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Elevation Angle
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '90'
    value: '45'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: beamforming_beamformer_py_cc_0
  id: beamforming_beamformer_py_cc
  parameters:
    fc: fc
    inputs_per_angle: 8*128
    mx: mx
    my: my
    phi_start: '0'
    theta_start: '0'
  states: {}
- name: beamforming_doaesprit_py_cf_0
  id: beamforming_doaesprit_py_cf
  parameters:
    decimation: '128'
    fc: fc
    mx: mx
    my: my
    n: n
  states: {}
- name: beamforming_phasedarray_py_cc_0
  id: beamforming_phasedarray_py_cc
  parameters:
    fc: fc
    mx: mx
    my: my
    noise: noise
    phi: phi
    theta: theta
  states: {}
- name: beamforming_randomsampler_py_cc_0_0
  id: beamforming_randomsampler_py_cc
  parameters:
    decimation: '8'
    vlen: mx*my
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /mnt/d/Users/grigo/Google Drive/Facultad/Balseiro/PI Lucas/git-repository/digital-beamforming/gr-beamforming/examples/files/sink.txt
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/grigosback/Documents/GNURadio/examples/sink.jpg
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /mnt/d/Users/grigo/Google Drive/Facultad/Balseiro/PI Lucas/git-repository/digital-beamforming/gr-beamforming/examples/files/source.txt
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/grigosback/Documents/GNURadio/examples/Grigolato - EEI (Small).jpg
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: bps
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: bps
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: const.points()
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: const.base()
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
  states: {state: disabled}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '2'
  states: {state: disabled}
- name: fc
  id: parameter
  parameters:
    label: Carrier frequency
    type: eng_float
    value: 436e6
  states: {}
- name: mx
  id: parameter
  parameters:
    label: '# elements in x'
    type: intx
    value: '4'
  states: {}
- name: my
  id: parameter
  parameters:
    label: '# elements in y'
    type: intx
    value: '4'
  states: {}
- name: n
  id: parameter
  parameters:
    label: '# impinging signals'
    type: intx
    value: '1'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 7,0,1,1
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 1,0,1,1
    max: '90'
    min: '0'
    name: '"Elevation"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 3,0,1,1
    max: '180'
    min: '-180'
    name: Azimut
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 6,0,1,1
    size: '512'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 5,0,1,1
    size: '512'
    srate: samp_rate
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: channel
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: channel
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:50001
    timeout: '100'
    type: complex
  states: {state: disabled}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:50001
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [beamforming_beamformer_py_cc_0, '0', blocks_null_sink_0, '0']
- [beamforming_beamformer_py_cc_0, '0', blocks_probe_rate_0, '0']
- [beamforming_beamformer_py_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [beamforming_beamformer_py_cc_0, '0', digital_gmsk_demod_0, '0']
- [beamforming_beamformer_py_cc_0, '0', qtgui_const_sink_x_0, '0']
- [beamforming_beamformer_py_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [beamforming_beamformer_py_cc_0, '0', qtgui_time_sink_x_0, '0']
- [beamforming_doaesprit_py_cf_0, '0', beamforming_beamformer_py_cc_0, '1']
- [beamforming_doaesprit_py_cf_0, '0', qtgui_number_sink_0, '0']
- [beamforming_doaesprit_py_cf_0, '1', beamforming_beamformer_py_cc_0, '2']
- [beamforming_doaesprit_py_cf_0, '1', qtgui_number_sink_0_0, '0']
- [beamforming_phasedarray_py_cc_0, '0', beamforming_beamformer_py_cc_0, '0']
- [beamforming_phasedarray_py_cc_0, '0', beamforming_randomsampler_py_cc_0_0, '0']
- [beamforming_randomsampler_py_cc_0_0, '0', beamforming_doaesprit_py_cf_0, '0']
- [blocks_file_source_0, '0', digital_gmsk_mod_0, '0']
- [blocks_file_source_0_0, '0', blocks_throttle_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_throttle_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_file_sink_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', virtual_sink_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_gmsk_demod_0, '0', blocks_file_sink_0, '0']
- [virtual_source_0, '0', beamforming_phasedarray_py_cc_0, '0']
- [zeromq_sub_source_0, '0', beamforming_phasedarray_py_cc_0, '0']

metadata:
  file_format: 1
