options:
  parameters:
    author: grigosback
    category: '[Beamforming]'
    description: Adaptive Beamformer for the reception of satellite signals
    generate_options: hb
    id: adaptive_beamformer_cc
    output_language: python
    title: Adaptive Beamformer
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: beamforming_beamformer_py_cc_0
  id: beamforming_beamformer_py_cc
  parameters:
    fc: fc
    inputs_per_angle: 8*128
    mx: mx
    my: my
    phi_start: '0'
    theta_start: '0'
  states: {}
- name: beamforming_doaesprit_py_cf_0
  id: beamforming_doaesprit_py_cf
  parameters:
    decimation: '128'
    fc: fc
    mx: mx
    my: my
    n: n
  states: {}
- name: beamforming_phasedarray_py_cc_0
  id: beamforming_phasedarray_py_cc
  parameters:
    fc: fc
    mx: mx
    my: my
    noise: noise
    phi: phi
    theta: theta
  states: {}
- name: beamforming_randomsampler_py_cc_0_0
  id: beamforming_randomsampler_py_cc
  parameters:
    decimation: rs_decimation
    vlen: mx*my
  states: {}
- name: esprit_decimation
  id: parameter
  parameters:
    label: ESPRIT decimation factor
    type: intx
    value: '128'
  states: {}
- name: fc
  id: parameter
  parameters:
    label: Carrier frequency
    type: eng_float
    value: 436e6
  states: {}
- name: mx
  id: parameter
  parameters:
    label: '# elements in x'
    type: intx
    value: '4'
  states: {}
- name: my
  id: parameter
  parameters:
    label: '# elements in y'
    type: intx
    value: '4'
  states: {}
- name: n
  id: parameter
  parameters:
    label: '# impinging signals'
    type: intx
    value: '1'
  states: {}
- name: noise
  id: parameter
  parameters:
    label: Noise voltage
    type: eng_float
    value: '0.1'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: phi
  id: parameter
  parameters:
    label: Azimut angle
    type: eng_float
    value: '50'
  states: {}
- name: phi_0
  id: parameter
  parameters:
    label: Azimut angle
    type: eng_float
    value: '50'
  states: {}
- name: rs_decimation
  id: parameter
  parameters:
    label: Random sampler decimation factor
    type: intx
    value: '8'
  states: {}
- name: theta
  id: parameter
  parameters:
    label: Elevation angle
    type: eng_float
    value: '30'
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: samples
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: samples
  states: {}

connections:
- [beamforming_beamformer_py_cc_0, '0', pad_sink_0, '0']
- [beamforming_doaesprit_py_cf_0, '0', beamforming_beamformer_py_cc_0, '1']
- [beamforming_doaesprit_py_cf_0, '1', beamforming_beamformer_py_cc_0, '2']
- [beamforming_phasedarray_py_cc_0, '0', beamforming_randomsampler_py_cc_0_0, '0']
- [beamforming_phasedarray_py_cc_0, '0', virtual_sink_0_0, '0']
- [beamforming_randomsampler_py_cc_0_0, '0', beamforming_doaesprit_py_cf_0, '0']
- [pad_source_0, '0', beamforming_phasedarray_py_cc_0, '0']
- [virtual_source_0_0, '0', beamforming_beamformer_py_cc_0, '0']

metadata:
  file_format: 1
