options:
  parameters:
    author: grigosback
    generate_options: qt_gui
    id: pi_simulation
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bps_1
  id: variable
  parameters:
    value: const_1.bits_per_symbol()
  states: {}
- name: bps_2
  id: variable
  parameters:
    value: const_2.bits_per_symbol()
  states: {}
- name: const_1
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: const_2
  id: variable_constellation
  parameters:
    precision: '8'
    type: 16qam
  states: {}
- name: element_separation
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Element separation distance [%
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '100'
    value: '10'
  states: {}
- name: noise_voltage_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Noise Voltage 1
    orient: Qt.Horizontal
    start: '0'
    step: '0.001'
    stop: '10'
    value: '2'
  states: {}
- name: phi
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: Azimut
    orient: Qt.Horizontal
    start: '-180'
    step: '0.1'
    stop: '180'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: theta
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Elevation
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '90'
    value: '0'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_vectornoise_source_0
  id: analog_vectornoise_source
  parameters:
    ampl: noise_voltage_1
    vlen: mx*my
  states: {}
- name: beamforming_beamformer_0
  id: beamforming_beamformer
  parameters:
    idx: '0'
    mx: mx
    my: my
  states: {}
- name: beamforming_doaesprit_py_cf_0
  id: beamforming_doaesprit_py_cf
  parameters:
    element_separation: (299792458/(2*fc))
    fc: fc
    mx: mx
    my: my
    n: n
    spd: '128'
  states: {}
- name: beamforming_phasedarray_0
  id: beamforming_phasedarray
  parameters:
    element_error: element_separation
    element_separation: (299792458/(2*fc))
    fc: 436e6
    mx: mx
    my: my
    phi: phi
    theta: theta
  states: {}
- name: beamforming_randomsampler_0
  id: beamforming_randomsampler
  parameters:
    decimation: '8'
    vlen: mx*my
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
    vlen: mx*my
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: bps_1
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: const_1.points()
  states: {}
- name: fc
  id: parameter
  parameters:
    label: Carrier frequency
    type: eng_float
    value: 436e6
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: mx
  id: parameter
  parameters:
    label: '# elements in x'
    type: intx
    value: '4'
  states: {}
- name: my
  id: parameter
  parameters:
    label: '# elements in y'
    type: intx
    value: '4'
  states: {}
- name: n
  id: parameter
  parameters:
    label: '# impinging signals'
    type: intx
    value: '2'
  states: {}
- name: phi_1
  id: parameter
  parameters:
    label: Azimut Angle 1
    type: eng_float
    value: '70'
  states: {}
- name: phi_2
  id: parameter
  parameters:
    label: Azimut Angle 2
    type: eng_float
    value: '41'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 5,0,1,1
    size: '1024'
    type: complex
  states: {}
- name: theta_1
  id: parameter
  parameters:
    label: Elevation Angle 1
    type: eng_float
    value: '45'
  states: {}
- name: theta_2
  id: parameter
  parameters:
    label: Elevation Angle 1
    type: eng_float
    value: '75'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: channel_1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: samples
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: channel_1
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: samples
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [analog_vectornoise_source_0, '0', blocks_add_xx_0, '1']
- [beamforming_beamformer_0, '0', qtgui_const_sink_x_0, '0']
- [beamforming_doaesprit_py_cf_0, doa_port, beamforming_beamformer_0, doa_port]
- [beamforming_phasedarray_0, '0', virtual_sink_0, '0']
- [beamforming_randomsampler_0, '0', beamforming_doaesprit_py_cf_0, '0']
- [blocks_add_xx_0, '0', beamforming_randomsampler_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_0_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_throttle_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', beamforming_phasedarray_0, '0']
- [virtual_source_0, '0', blocks_add_xx_0, '0']
- [virtual_source_0_0, '0', beamforming_beamformer_0, '0']

metadata:
  file_format: 1
