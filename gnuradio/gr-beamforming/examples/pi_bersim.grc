options:
  parameters:
    author: grigosback
    generate_options: qt_gui
    id: pi_bersim
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: N_BITS
  id: variable
  parameters:
    value: 1e5
  states: {}
- name: RAND_SEED
  id: variable
  parameters:
    value: '42'
  states: {}
- name: SKIP
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: const
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: intdump_decim
  id: variable
  parameters:
    value: min(int(N_BITS / 10), 100000)
  states: {}
- name: noise_voltage
  id: variable
  parameters:
    value: 1.0 / math.sqrt(1 / float(sps) * 10 ** (float(EbN0) / 10))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '5'
  states: {}
- name: EbN0
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: analog_vectornoise_source_0
  id: analog_vectornoise_source
  parameters:
    ampl: noise_voltage
    vlen: mx*my
  states: {}
- name: beamforming_beamformer_0
  id: beamforming_beamformer
  parameters:
    idx: '0'
    mx: mx
    my: my
  states: {}
- name: beamforming_doaesprit_py_cf_0
  id: beamforming_doaesprit_py_cf
  parameters:
    element_separation: (299792458/(2*fc))
    fc: fc
    file_name: eigenvalues.csv
    mx: mx
    my: my
    n: n
    spd: '128'
  states: {}
- name: beamforming_phasedarray_0
  id: beamforming_phasedarray
  parameters:
    element_error: element_error
    element_separation: (299792458/(2*fc))
    fc: fc
    mx: mx
    my: my
    phi: phi
    theta: theta
  states: {}
- name: beamforming_randomsampler_0
  id: beamforming_randomsampler
  parameters:
    decimation: rs_decimation
    vlen: mx*my
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
    vlen: mx*my
  states: {}
- name: blocks_and_const_xx_0
  id: blocks_and_const_xx
  parameters:
    const: '1'
    type: byte
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(N_BITS)
    type: byte
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: intdump_decim
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0 / intdump_decim
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.1'
    type: complex
  states: {}
- name: blocks_not_xx_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: SKIP
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vector_sink_x_0
  id: blocks_vector_sink_x
  parameters:
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[1]'
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: const
    differential: 'False'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    len: '16'
    mask: '0x21'
    seed: '0x00'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '2'
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    modulus: '2'
  states: {}
- name: digital_scrambler_bb_0
  id: digital_scrambler_bb
  parameters:
    len: '16'
    mask: '0x21'
    seed: '0x0'
  states: {}
- name: element_error
  id: parameter
  parameters:
    label: Element Separation Error [%]
    value: '0'
  states: {}
- name: element_error_0
  id: parameter
  parameters:
    label: Element Separation Error [%]
    value: '0'
  states: {}
- name: esprit_decimation
  id: parameter
  parameters:
    label: ESPRIT decimation factor
    type: intx
    value: '128'
  states: {}
- name: fc
  id: parameter
  parameters:
    label: Carrier frequency
    type: eng_float
    value: 436e6
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: (0, 0, (1 + 1j) / numpy.sqrt(2),)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_1
  id: import
  parameters:
    imports: import pylab
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from scipy.special import erfc
  states: {}
- name: lilacsat1_ber_bpsk_0
  id: lilacsat1_ber_bpsk
  parameters:
    bfo: '12000'
    callsign: '""'
    ip: '"::"'
    latitude: '0'
    longitude: '0'
    port: '7355'
    recstart: '""'
  states: {}
- name: mx
  id: parameter
  parameters:
    label: '# elements in x'
    type: intx
    value: '4'
  states: {}
- name: my
  id: parameter
  parameters:
    label: '# elements in y'
    type: intx
    value: '4'
  states: {}
- name: n
  id: parameter
  parameters:
    label: '# impinging signals'
    type: intx
    value: '1'
  states: {}
- name: phi
  id: parameter
  parameters:
    label: Azimut angle
    type: eng_float
    value: '50'
  states: {}
- name: rs_decimation
  id: parameter
  parameters:
    label: Random sampler decimation factor
    type: intx
    value: '8'
  states: {}
- name: theta
  id: parameter
  parameters:
    label: Elevation angle
    type: eng_float
    value: '30'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: channel
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: samples
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: channel
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: samples
  states: {}

connections:
- [analog_vectornoise_source_0, '0', blocks_add_xx_0, '1']
- [beamforming_beamformer_0, '0', blocks_multiply_const_vxx_1, '0']
- [beamforming_doaesprit_py_cf_0, doa_port, beamforming_beamformer_0, doa_port]
- [beamforming_phasedarray_0, '0', virtual_sink_0, '0']
- [beamforming_randomsampler_0, '0', beamforming_doaesprit_py_cf_0, '0']
- [blocks_add_xx_0, '0', beamforming_randomsampler_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_0_0, '0']
- [blocks_and_const_xx_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_head_0, '0', digital_scrambler_bb_0, '0']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_vector_sink_x_0, '0']
- [blocks_multiply_const_vxx_1, '0', lilacsat1_ber_bpsk_0, '0']
- [blocks_not_xx_0, '0', blocks_and_const_xx_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_constellation_modulator_0, '0']
- [blocks_skiphead_0, '0', blocks_not_xx_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_integrate_xx_0, '0']
- [blocks_vector_source_x_0, '0', blocks_head_0, '0']
- [digital_constellation_modulator_0, '0', fir_filter_xxx_0, '0']
- [digital_descrambler_bb_0, '0', blocks_skiphead_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_descrambler_bb_0, '0']
- [digital_diff_encoder_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_scrambler_bb_0, '0', digital_diff_encoder_bb_0, '0']
- [fir_filter_xxx_0, '0', beamforming_phasedarray_0, '0']
- [lilacsat1_ber_bpsk_0, '0', digital_diff_decoder_bb_0, '0']
- [virtual_source_0, '0', blocks_add_xx_0, '0']
- [virtual_source_0_0, '0', beamforming_beamformer_0, '0']

metadata:
  file_format: 1
