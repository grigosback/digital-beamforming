options:
  parameters:
    generate_options: qt_gui
    id: ber_simulation
    output_language: python
    title: BER Simulation
  states: {}

blocks:
- name: EbN0
  id: variable
  parameters:
    value: '0'
  states: {}
- name: N_BITS
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: RAND_SEED
  id: variable
  parameters:
    value: '42'
  states: {}
- name: SKIP
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: const
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: intdump_decim
  id: variable
  parameters:
    value: min(int(N_BITS / 10), 100000)
  states: {}
- name: noise_voltage
  id: variable
  parameters:
    value: 0.5 * erfc(math.sqrt(10 ** (float(EbN0) / 10)))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '5'
  states: {}
- name: blocks_and_const_xx_0
  id: blocks_and_const_xx
  parameters:
    const: '1'
    type: byte
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(N_BITS)
    type: byte
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: intdump_decim
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0 / intdump_decim
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.1'
    type: complex
  states: {}
- name: blocks_not_xx_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: SKIP
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vector_sink_x_0
  id: blocks_vector_sink_x
  parameters:
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '1'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: noise_voltage
    seed: RAND_SEED
    taps: (0, 0, (1 + 1j) / numpy.sqrt(2),)
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: const
    differential: 'False'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    len: '16'
    mask: '0x21'
    seed: '0x00'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '2'
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    modulus: '2'
  states: {}
- name: digital_scrambler_bb_0
  id: digital_scrambler_bb
  parameters:
    len: '16'
    mask: '0x21'
    seed: '0x0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from scipy.special import erfc
  states: {}
- name: lilacsat1_ber_bpsk_0
  id: lilacsat1_ber_bpsk
  parameters:
    bfo: '12000'
    callsign: '""'
    ip: '"::"'
    latitude: '0'
    longitude: '0'
    port: '7355'
    recstart: '""'
  states: {}

connections:
- [blocks_and_const_xx_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_head_0, '0', digital_scrambler_bb_0, '0']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_vector_sink_x_0, '0']
- [blocks_multiply_const_vxx_1, '0', lilacsat1_ber_bpsk_0, '0']
- [blocks_not_xx_0, '0', blocks_and_const_xx_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_constellation_modulator_0, '0']
- [blocks_skiphead_0, '0', blocks_not_xx_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_integrate_xx_0, '0']
- [blocks_vector_source_x_0, '0', blocks_head_0, '0']
- [channels_channel_model_0, '0', blocks_multiply_const_vxx_1, '0']
- [digital_constellation_modulator_0, '0', channels_channel_model_0, '0']
- [digital_descrambler_bb_0, '0', blocks_skiphead_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_descrambler_bb_0, '0']
- [digital_diff_encoder_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_scrambler_bb_0, '0', digital_diff_encoder_bb_0, '0']
- [lilacsat1_ber_bpsk_0, '0', digital_diff_decoder_bb_0, '0']

metadata:
  file_format: 1
