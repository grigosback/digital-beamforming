options:
  parameters:
    author: grigosback
    generate_options: qt_gui
    id: doaesprit_test
    output_language: python
    title: DoA Esprit Estimation - Test
  states: {}

blocks:
- name: bps
  id: variable
  parameters:
    value: const.bits_per_symbol()
  states: {}
- name: const
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    label: Noise Voltage
    orient: Qt.Horizontal
    start: '0'
    step: '0.001'
    stop: '10'
    value: '0'
  states: {}
- name: phi
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Azimut Angle
    orient: Qt.Horizontal
    start: '-180'
    step: '1'
    stop: '180'
    value: '70'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: theta
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Elevation Angle
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '90'
    value: '45'
  states: {}
- name: beamforming_beamformer_0
  id: beamforming_beamformer
  parameters:
    mx: mx
    my: my
  states: {}
- name: beamforming_beamformer_py_cc_0
  id: beamforming_beamformer_py_cc
  parameters:
    fc: fc
    inputs_per_angle: 8*128
    mx: mx
    my: my
    phi_start: '0'
    theta_start: '0'
  states: {state: disabled}
- name: beamforming_doaesprit_py_cf_0
  id: beamforming_doaesprit_py_cf
  parameters:
    decimation: '128'
    fc: fc
    mx: mx
    my: my
    n: n
  states: {}
- name: beamforming_phasedarray_0
  id: beamforming_phasedarray
  parameters:
    element_error: '0'
    element_separation: (299792458/(2*fc))
    fc: 436e6
    mx: mx
    my: my
    phi: phi
    theta: theta
  states: {}
- name: beamforming_phasedarray_py_cc_0
  id: beamforming_phasedarray_py_cc
  parameters:
    fc: fc
    mx: mx
    my: my
    noise: noise
    phi: phi
    theta: theta
  states: {state: disabled}
- name: beamforming_randomsampler_py_cc_0_0
  id: beamforming_randomsampler_py_cc
  parameters:
    decimation: '8'
    vlen: mx*my
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/grigosback/Documents/GNURadio/examples/sink.txt
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/grigosback/Documents/GNURadio/examples/source.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: bps
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: bps
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: const.points()
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: const.base()
  states: {}
- name: fc
  id: parameter
  parameters:
    label: Carrier frequency
    type: eng_float
    value: 436e6
  states: {}
- name: mx
  id: parameter
  parameters:
    label: '# elements in x'
    type: intx
    value: '4'
  states: {}
- name: my
  id: parameter
  parameters:
    label: '# elements in y'
    type: intx
    value: '4'
  states: {}
- name: n
  id: parameter
  parameters:
    label: '# impinging signals'
    type: intx
    value: '1'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 7,0,1,1
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 8,0,1,1
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 1,0,1,1
    max: '90'
    min: '0'
    name: '"Elevation"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 3,0,1,1
    max: '180'
    min: '-180'
    name: Azimut
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 6,0,1,1
    size: '128'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 5,0,1,1
    size: '128'
    srate: samp_rate
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: channel
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: samples
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: channel
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: samples
  states: {}
- name: zeromq_req_msg_source_0
  id: zeromq_req_msg_source
  parameters:
    address: tcp://127.0.0.1:5558
    timeout: '100'
  states: {}

connections:
- [beamforming_beamformer_0, '0', digital_constellation_decoder_cb_0, '0']
- [beamforming_beamformer_0, '0', qtgui_const_sink_x_0, '0']
- [beamforming_beamformer_0, '0', qtgui_time_sink_x_0, '0']
- [beamforming_beamformer_py_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [beamforming_beamformer_py_cc_0, '0', qtgui_const_sink_x_0, '0']
- [beamforming_beamformer_py_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [beamforming_beamformer_py_cc_0, '0', qtgui_time_sink_x_0, '0']
- [beamforming_doaesprit_py_cf_0, '0', beamforming_beamformer_py_cc_0, '1']
- [beamforming_doaesprit_py_cf_0, '0', qtgui_number_sink_0, '0']
- [beamforming_doaesprit_py_cf_0, '1', beamforming_beamformer_py_cc_0, '2']
- [beamforming_doaesprit_py_cf_0, '1', qtgui_number_sink_0_0, '0']
- [beamforming_phasedarray_0, '0', beamforming_randomsampler_py_cc_0_0, '0']
- [beamforming_phasedarray_0, '0', virtual_sink_0_0, '0']
- [beamforming_phasedarray_py_cc_0, '0', beamforming_randomsampler_py_cc_0_0, '0']
- [beamforming_phasedarray_py_cc_0, '0', virtual_sink_0_0, '0']
- [beamforming_randomsampler_py_cc_0_0, '0', beamforming_doaesprit_py_cf_0, '0']
- [blocks_file_source_0_0, '0', blocks_throttle_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_throttle_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_file_sink_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', virtual_sink_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [virtual_source_0, '0', beamforming_phasedarray_0, '0']
- [virtual_source_0, '0', beamforming_phasedarray_py_cc_0, '0']
- [virtual_source_0_0, '0', beamforming_beamformer_0, '0']
- [virtual_source_0_0, '0', beamforming_beamformer_py_cc_0, '0']
- [zeromq_req_msg_source_0, out, beamforming_beamformer_0, doa_port]

metadata:
  file_format: 1
