options:
  parameters:
    author: grigosback
    generate_options: qt_gui
    id: adaptive_beamformer_test
    output_language: python
    title: Adaptive Beamformer Test
  states: {}

blocks:
- name: bps
  id: variable
  parameters:
    value: const.bits_per_symbol()
  states: {}
- name: const
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    label: Noise Voltage
    orient: Qt.Horizontal
    start: '0'
    step: '0.001'
    stop: '10'
    value: '0'
  states: {}
- name: phi
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Azimut Angle
    orient: Qt.Horizontal
    start: '-180'
    step: '1'
    stop: '180'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48'
  states: {}
- name: theta
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Elevation Angle
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '90'
    value: '45'
  states: {}
- name: adaptive_beamformer_cc_0
  id: adaptive_beamformer_cc
  parameters:
    esprit_decimation: '128'
    fc: 436e6
    mx: '4'
    my: '4'
    n: '1'
    noise: '0.1'
    phi: '50'
    phi_0: '50'
    rs_decimation: '8'
    theta: '30'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/grigosback/Documents/GNURadio/examples/sink.txt
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/grigosback/Documents/GNURadio/examples/source.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: bps
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: bps
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: const.points()
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: const.base()
  states: {}
- name: fc
  id: parameter
  parameters:
    label: Carrier frequency
    type: eng_float
    value: 436e6
  states: {}
- name: mx
  id: parameter
  parameters:
    label: '# elements in x'
    type: intx
    value: '4'
  states: {}
- name: my
  id: parameter
  parameters:
    label: '# elements in y'
    type: intx
    value: '4'
  states: {}
- name: n
  id: parameter
  parameters:
    label: '# impinging signals'
    type: intx
    value: '1'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 5,0,1,1
    size: '128'
    srate: samp_rate
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: channel
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: channel
  states: {}

connections:
- [adaptive_beamformer_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_file_source_0_0, '0', blocks_throttle_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_throttle_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_file_sink_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', virtual_sink_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [virtual_source_0, '0', adaptive_beamformer_cc_0, '0']

metadata:
  file_format: 1
