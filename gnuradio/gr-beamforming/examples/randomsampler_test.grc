options:
  parameters:
    author: grigosback
    generate_options: qt_gui
    id: randomsampler_test
    output_language: python
    title: randomsampler_test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: beamforming_randomsampler_py_cc_0_0
  id: beamforming_randomsampler_py_cc
  parameters:
    decimation: '8'
    vlen: '4'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '4'
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: range(1024)
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '4'
    type: complex
  states: {}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '10000'
    min: '0'
    name: '"Output stream"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '10000'
    min: '0'
    name: '"Input stream"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    name: '"Input stream"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Output stream"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [beamforming_randomsampler_py_cc_0_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_number_sink_0_0_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_float_to_complex_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_stream_to_vector_0_0, '0', beamforming_randomsampler_py_cc_0_0, '0']
- [blocks_throttle_0_0, '0', blocks_float_to_complex_0_0, '0']
- [blocks_throttle_0_0, '0', qtgui_number_sink_0_0_0_0, '0']
- [blocks_throttle_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_throttle_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_real_0, '0']

metadata:
  file_format: 1
