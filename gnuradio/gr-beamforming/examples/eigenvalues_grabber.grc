options:
  parameters:
    author: grigosback
    generate_options: no_gui
    id: eigenvalues_grabber
    output_language: python
    title: Eigenvalues Grabber
  states: {}

blocks:
- name: bps_1
  id: variable
  parameters:
    value: const_1.bits_per_symbol()
  states: {}
- name: bps_2
  id: variable
  parameters:
    value: const_2.bits_per_symbol()
  states: {}
- name: bps_3
  id: variable
  parameters:
    value: const_3.bits_per_symbol()
  states: {}
- name: bps_4
  id: variable
  parameters:
    value: const_4.bits_per_symbol()
  states: {}
- name: bps_5
  id: variable
  parameters:
    value: const_5.bits_per_symbol()
  states: {}
- name: bps_6
  id: variable
  parameters:
    value: const_6.bits_per_symbol()
  states: {}
- name: bps_7
  id: variable
  parameters:
    value: const_7.bits_per_symbol()
  states: {}
- name: bps_8
  id: variable
  parameters:
    value: const_8.bits_per_symbol()
  states: {}
- name: const_1
  id: variable_constellation
  parameters:
    precision: '8'
    type: 8psk
  states: {}
- name: const_2
  id: variable_constellation
  parameters:
    precision: '8'
    type: 16qam
  states: {}
- name: const_3
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: const_4
  id: variable_constellation
  parameters:
    precision: '8'
    type: 16qam
  states: {}
- name: const_5
  id: variable_constellation
  parameters:
    precision: '8'
    type: 8psk
  states: {}
- name: const_6
  id: variable_constellation
  parameters:
    precision: '8'
    type: 16qam
  states: {}
- name: const_7
  id: variable_constellation
  parameters:
    precision: '8'
    type: 8psk
  states: {}
- name: const_8
  id: variable_constellation
  parameters:
    precision: '8'
    type: 16qam
  states: {}
- name: fc
  id: variable
  parameters:
    value: 436e6
  states: {}
- name: mx
  id: variable
  parameters:
    value: '4'
  states: {}
- name: my
  id: variable
  parameters:
    value: '4'
  states: {}
- name: n
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '150000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '10000'
    repeat: 'False'
    type: byte
  states: {}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '10000'
    repeat: 'False'
    type: byte
  states: {}
- name: analog_random_source_x_0_0_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '10000'
    repeat: 'False'
    type: byte
  states: {}
- name: analog_random_source_x_0_0_0_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '10000'
    repeat: 'False'
    type: byte
  states: {}
- name: analog_random_source_x_0_0_0_0_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '10000'
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: analog_random_source_x_0_0_0_0_0_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '10000'
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: analog_random_source_x_0_0_0_0_0_0_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '10000'
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: analog_random_source_x_0_0_0_0_0_0_0_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '10000'
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: analog_vectornoise_source_0
  id: analog_vectornoise_source
  parameters:
    ampl: noise_voltage_1
    vlen: mx*my
  states: {}
- name: analog_vectornoise_source_0_0
  id: analog_vectornoise_source
  parameters:
    ampl: noise_voltage_2
    vlen: mx*my
  states: {}
- name: analog_vectornoise_source_0_0_0
  id: analog_vectornoise_source
  parameters:
    ampl: noise_voltage_4
    vlen: mx*my
  states: {}
- name: analog_vectornoise_source_0_0_0_0
  id: analog_vectornoise_source
  parameters:
    ampl: noise_voltage_8
    vlen: mx*my
  states: {state: disabled}
- name: analog_vectornoise_source_0_0_1
  id: analog_vectornoise_source
  parameters:
    ampl: noise_voltage_6
    vlen: mx*my
  states: {state: disabled}
- name: analog_vectornoise_source_0_1
  id: analog_vectornoise_source
  parameters:
    ampl: noise_voltage_3
    vlen: mx*my
  states: {}
- name: analog_vectornoise_source_0_1_0
  id: analog_vectornoise_source
  parameters:
    ampl: noise_voltage_7
    vlen: mx*my
  states: {state: disabled}
- name: analog_vectornoise_source_0_2
  id: analog_vectornoise_source
  parameters:
    ampl: noise_voltage_5
    vlen: mx*my
  states: {state: disabled}
- name: beamforming_doaesprit_py_cf_0
  id: beamforming_doaesprit_py_cf
  parameters:
    element_separation: (299792458/(2*fc))
    fc: fc
    file_name: file_name
    mx: mx
    my: my
    n: n
    spd: '128'
  states: {}
- name: beamforming_phasedarray_0
  id: beamforming_phasedarray
  parameters:
    element_error: element_separation
    element_separation: (299792458/(2*fc))
    fc: 436e6
    mx: mx
    my: my
    phi: phi_1
    theta: theta_1
  states: {}
- name: beamforming_phasedarray_0_0
  id: beamforming_phasedarray
  parameters:
    element_error: element_separation
    element_separation: (299792458/(2*fc))
    fc: 436e6
    mx: mx
    my: my
    phi: phi_2
    theta: theta_2
  states: {}
- name: beamforming_phasedarray_0_0_0
  id: beamforming_phasedarray
  parameters:
    element_error: element_separation
    element_separation: (299792458/(2*fc))
    fc: 436e6
    mx: mx
    my: my
    phi: phi_3
    theta: theta_3
  states: {}
- name: beamforming_phasedarray_0_0_0_0
  id: beamforming_phasedarray
  parameters:
    element_error: element_separation
    element_separation: (299792458/(2*fc))
    fc: 436e6
    mx: mx
    my: my
    phi: phi_4
    theta: theta_4
  states: {}
- name: beamforming_phasedarray_0_0_0_0_0
  id: beamforming_phasedarray
  parameters:
    element_error: element_separation
    element_separation: (299792458/(2*fc))
    fc: 436e6
    mx: mx
    my: my
    phi: phi_5
    theta: theta_5
  states: {state: disabled}
- name: beamforming_phasedarray_0_0_0_0_0_0
  id: beamforming_phasedarray
  parameters:
    element_error: element_separation
    element_separation: (299792458/(2*fc))
    fc: 436e6
    mx: mx
    my: my
    phi: phi_6
    theta: theta_6
  states: {state: disabled}
- name: beamforming_phasedarray_0_0_0_0_0_0_0
  id: beamforming_phasedarray
  parameters:
    element_error: element_separation
    element_separation: (299792458/(2*fc))
    fc: 436e6
    mx: mx
    my: my
    phi: phi_7
    theta: theta_7
  states: {state: disabled}
- name: beamforming_phasedarray_0_0_0_0_0_0_0_0
  id: beamforming_phasedarray
  parameters:
    element_error: element_separation
    element_separation: (299792458/(2*fc))
    fc: 436e6
    mx: mx
    my: my
    phi: phi_8
    theta: theta_8
  states: {state: disabled}
- name: beamforming_randomsampler_0
  id: beamforming_randomsampler
  parameters:
    decimation: '8'
    vlen: mx*my
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
    vlen: mx*my
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
    vlen: mx*my
  states: {}
- name: blocks_add_xx_0_0_0
  id: blocks_add_xx
  parameters:
    type: complex
    vlen: mx*my
  states: {}
- name: blocks_add_xx_0_0_0_0
  id: blocks_add_xx
  parameters:
    type: complex
    vlen: mx*my
  states: {state: disabled}
- name: blocks_add_xx_0_0_1
  id: blocks_add_xx
  parameters:
    type: complex
    vlen: mx*my
  states: {state: disabled}
- name: blocks_add_xx_0_1
  id: blocks_add_xx
  parameters:
    type: complex
    vlen: mx*my
  states: {}
- name: blocks_add_xx_0_1_0
  id: blocks_add_xx
  parameters:
    type: complex
    vlen: mx*my
  states: {state: disabled}
- name: blocks_add_xx_0_2
  id: blocks_add_xx
  parameters:
    type: complex
    vlen: mx*my
  states: {state: disabled}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
    vlen: mx*my
  states: {}
- name: blocks_add_xx_1_0
  id: blocks_add_xx
  parameters:
    type: complex
    vlen: mx*my
  states: {}
- name: blocks_add_xx_1_0_0
  id: blocks_add_xx
  parameters:
    type: complex
    vlen: mx*my
  states: {state: disabled}
- name: blocks_add_xx_1_0_0_0
  id: blocks_add_xx
  parameters:
    type: complex
    vlen: mx*my
  states: {state: disabled}
- name: blocks_add_xx_1_0_0_0_0
  id: blocks_add_xx
  parameters:
    type: complex
    vlen: mx*my
  states: {state: disabled}
- name: blocks_add_xx_1_0_0_0_0_0
  id: blocks_add_xx
  parameters:
    type: complex
    vlen: mx*my
  states: {}
- name: blocks_add_xx_1_0_0_0_0_0_0
  id: blocks_add_xx
  parameters:
    type: complex
    vlen: mx*my
  states: {state: disabled}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: bps_1
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_0_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: bps_2
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_0_0_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: bps_3
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_0_0_0_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: bps_4
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_0_0_0_0_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: bps_5
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_packed_to_unpacked_xx_0_0_0_0_0_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: bps_6
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_packed_to_unpacked_xx_0_0_0_0_0_0_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: bps_7
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_packed_to_unpacked_xx_0_0_0_0_0_0_0_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: bps_8
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_throttle_0_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_throttle_0_0_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {state: disabled}
- name: blocks_throttle_0_0_0_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {state: disabled}
- name: blocks_throttle_0_0_0_0_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {state: disabled}
- name: blocks_throttle_0_0_0_0_0_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {state: disabled}
- name: const_1_name
  id: parameter
  parameters:
    type: str
    value: '"BPSK"'
  states: {}
- name: const_2_name
  id: parameter
  parameters:
    type: str
    value: '"QPSK"'
  states: {}
- name: const_3_name
  id: parameter
  parameters:
    type: str
    value: '"BPSK"'
  states: {}
- name: const_4_name
  id: parameter
  parameters:
    type: str
    value: '"QPSK"'
  states: {}
- name: const_5_name
  id: parameter
  parameters:
    type: str
    value: '"BPSK"'
  states: {}
- name: const_6_name
  id: parameter
  parameters:
    type: str
    value: '"QPSK"'
  states: {}
- name: const_7_name
  id: parameter
  parameters:
    type: str
    value: '"BPSK"'
  states: {}
- name: const_8_name
  id: parameter
  parameters:
    type: str
    value: '"QPSK"'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: const_1.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: const_2.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: const_3.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_0_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: const_4.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_0_0_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: const_5.points()
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0_0_0_0_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: const_6.points()
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0_0_0_0_0_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: const_7.points()
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0_0_0_0_0_0_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: const_8.points()
  states: {state: disabled}
- name: element_separation
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: file_name
  id: parameter
  parameters:
    type: str
    value: '"eigenvalues5.csv"'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import random
  states: {}
- name: noise_voltage_1
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: noise_voltage_2
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: noise_voltage_3
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: noise_voltage_4
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: noise_voltage_5
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: noise_voltage_6
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: noise_voltage_7
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: noise_voltage_8
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: phi_1
  id: parameter
  parameters:
    label: Azimut Angle 1
    type: eng_float
    value: '70'
  states: {}
- name: phi_2
  id: parameter
  parameters:
    label: Azimut Angle 2
    type: eng_float
    value: '41'
  states: {}
- name: phi_3
  id: parameter
  parameters:
    label: Azimut Angle 3
    type: eng_float
    value: '70'
  states: {}
- name: phi_4
  id: parameter
  parameters:
    label: Azimut Angle 4
    type: eng_float
    value: '41'
  states: {}
- name: phi_5
  id: parameter
  parameters:
    label: Azimut Angle 5
    type: eng_float
    value: '70'
  states: {}
- name: phi_6
  id: parameter
  parameters:
    label: Azimut Angle 6
    type: eng_float
    value: '41'
  states: {}
- name: phi_7
  id: parameter
  parameters:
    label: Azimut Angle 7
    type: eng_float
    value: '70'
  states: {}
- name: phi_8
  id: parameter
  parameters:
    label: Azimut Angle 8
    type: eng_float
    value: '41'
  states: {}
- name: theta_1
  id: parameter
  parameters:
    label: Elevation Angle 1
    type: eng_float
    value: '45'
  states: {}
- name: theta_2
  id: parameter
  parameters:
    label: Elevation Angle 2
    type: eng_float
    value: '75'
  states: {}
- name: theta_3
  id: parameter
  parameters:
    label: Elevation Angle 3
    type: eng_float
    value: '45'
  states: {}
- name: theta_4
  id: parameter
  parameters:
    label: Elevation Angle 4
    type: eng_float
    value: '75'
  states: {}
- name: theta_5
  id: parameter
  parameters:
    label: Elevation Angle 5
    type: eng_float
    value: '45'
  states: {}
- name: theta_6
  id: parameter
  parameters:
    label: Elevation Angle 6
    type: eng_float
    value: '75'
  states: {}
- name: theta_7
  id: parameter
  parameters:
    label: Elevation Angle 7
    type: eng_float
    value: '45'
  states: {}
- name: theta_8
  id: parameter
  parameters:
    label: Elevation Angle 8
    type: eng_float
    value: '75'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: channel_1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: samples
  states: {state: disabled}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: channel_2
  states: {}
- name: virtual_sink_0_1_0
  id: virtual_sink
  parameters:
    stream_id: channel_3
  states: {}
- name: virtual_sink_0_1_0_0
  id: virtual_sink
  parameters:
    stream_id: channel_4
  states: {}
- name: virtual_sink_0_1_0_0_0
  id: virtual_sink
  parameters:
    stream_id: channel_5
  states: {state: disabled}
- name: virtual_sink_0_1_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: channel_6
  states: {state: disabled}
- name: virtual_sink_0_1_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: channel_7
  states: {state: disabled}
- name: virtual_sink_0_1_0_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: channel_8
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: channel_1
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: channel_3
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: channel_7
  states: {state: disabled}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: channel_2
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: channel_4
  states: {}
- name: virtual_source_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: channel_8
  states: {state: disabled}
- name: virtual_source_0_1_1
  id: virtual_source
  parameters:
    stream_id: channel_6
  states: {state: disabled}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: channel_5
  states: {state: disabled}

connections:
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [analog_random_source_x_0_0, '0', blocks_throttle_0_0, '0']
- [analog_random_source_x_0_0_0, '0', blocks_throttle_0_0_0, '0']
- [analog_random_source_x_0_0_0_0, '0', blocks_throttle_0_0_0_0, '0']
- [analog_random_source_x_0_0_0_0_0, '0', blocks_throttle_0_0_0_0_0, '0']
- [analog_random_source_x_0_0_0_0_0_0, '0', blocks_throttle_0_0_0_0_0_0, '0']
- [analog_random_source_x_0_0_0_0_0_0_0, '0', blocks_throttle_0_0_0_0_0_0_0, '0']
- [analog_random_source_x_0_0_0_0_0_0_0_0, '0', blocks_throttle_0_0_0_0_0_0_0_0, '0']
- [analog_vectornoise_source_0, '0', blocks_add_xx_0, '1']
- [analog_vectornoise_source_0_0, '0', blocks_add_xx_0_0, '1']
- [analog_vectornoise_source_0_0_0, '0', blocks_add_xx_0_0_0, '1']
- [analog_vectornoise_source_0_0_0_0, '0', blocks_add_xx_0_0_0_0, '1']
- [analog_vectornoise_source_0_0_1, '0', blocks_add_xx_0_0_1, '1']
- [analog_vectornoise_source_0_1, '0', blocks_add_xx_0_1, '1']
- [analog_vectornoise_source_0_1_0, '0', blocks_add_xx_0_1_0, '1']
- [analog_vectornoise_source_0_2, '0', blocks_add_xx_0_2, '1']
- [beamforming_phasedarray_0, '0', virtual_sink_0, '0']
- [beamforming_phasedarray_0_0, '0', virtual_sink_0_1, '0']
- [beamforming_phasedarray_0_0_0, '0', virtual_sink_0_1_0, '0']
- [beamforming_phasedarray_0_0_0_0, '0', virtual_sink_0_1_0_0, '0']
- [beamforming_phasedarray_0_0_0_0_0, '0', virtual_sink_0_1_0_0_0, '0']
- [beamforming_phasedarray_0_0_0_0_0_0, '0', virtual_sink_0_1_0_0_0_0, '0']
- [beamforming_phasedarray_0_0_0_0_0_0_0, '0', virtual_sink_0_1_0_0_0_0_0, '0']
- [beamforming_phasedarray_0_0_0_0_0_0_0_0, '0', virtual_sink_0_1_0_0_0_0_0_0, '0']
- [beamforming_randomsampler_0, '0', beamforming_doaesprit_py_cf_0, '0']
- [blocks_add_xx_0, '0', blocks_add_xx_1, '0']
- [blocks_add_xx_0_0, '0', blocks_add_xx_1, '1']
- [blocks_add_xx_0_0_0, '0', blocks_add_xx_1_0, '1']
- [blocks_add_xx_0_0_0_0, '0', blocks_add_xx_1_0_0_0, '1']
- [blocks_add_xx_0_0_1, '0', blocks_add_xx_1_0_0, '1']
- [blocks_add_xx_0_1, '0', blocks_add_xx_1_0, '0']
- [blocks_add_xx_0_1_0, '0', blocks_add_xx_1_0_0_0, '0']
- [blocks_add_xx_0_2, '0', blocks_add_xx_1_0_0, '0']
- [blocks_add_xx_1, '0', blocks_add_xx_1_0_0_0_0_0, '0']
- [blocks_add_xx_1, '0', virtual_sink_0_0, '0']
- [blocks_add_xx_1_0, '0', blocks_add_xx_1_0_0_0_0_0, '1']
- [blocks_add_xx_1_0_0, '0', blocks_add_xx_1_0_0_0_0, '0']
- [blocks_add_xx_1_0_0_0, '0', blocks_add_xx_1_0_0_0_0, '1']
- [blocks_add_xx_1_0_0_0_0, '0', blocks_add_xx_1_0_0_0_0_0_0, '1']
- [blocks_add_xx_1_0_0_0_0_0, '0', beamforming_randomsampler_0, '0']
- [blocks_add_xx_1_0_0_0_0_0, '0', blocks_add_xx_1_0_0_0_0_0_0, '0']
- [blocks_add_xx_1_0_0_0_0_0_0, '0', beamforming_randomsampler_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_packed_to_unpacked_xx_0_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [blocks_packed_to_unpacked_xx_0_0_0, '0', digital_chunks_to_symbols_xx_0_0_0, '0']
- [blocks_packed_to_unpacked_xx_0_0_0_0, '0', digital_chunks_to_symbols_xx_0_0_0_0, '0']
- [blocks_packed_to_unpacked_xx_0_0_0_0_0, '0', digital_chunks_to_symbols_xx_0_0_0_0_0, '0']
- [blocks_packed_to_unpacked_xx_0_0_0_0_0_0, '0', digital_chunks_to_symbols_xx_0_0_0_0_0_0, '0']
- [blocks_packed_to_unpacked_xx_0_0_0_0_0_0_0, '0', digital_chunks_to_symbols_xx_0_0_0_0_0_0_0, '0']
- [blocks_packed_to_unpacked_xx_0_0_0_0_0_0_0_0, '0', digital_chunks_to_symbols_xx_0_0_0_0_0_0_0_0, '0']
- [blocks_throttle_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_throttle_0_0, '0', blocks_packed_to_unpacked_xx_0_0, '0']
- [blocks_throttle_0_0_0, '0', blocks_packed_to_unpacked_xx_0_0_0, '0']
- [blocks_throttle_0_0_0_0, '0', blocks_packed_to_unpacked_xx_0_0_0_0, '0']
- [blocks_throttle_0_0_0_0_0, '0', blocks_packed_to_unpacked_xx_0_0_0_0_0, '0']
- [blocks_throttle_0_0_0_0_0_0, '0', blocks_packed_to_unpacked_xx_0_0_0_0_0_0, '0']
- [blocks_throttle_0_0_0_0_0_0_0, '0', blocks_packed_to_unpacked_xx_0_0_0_0_0_0_0, '0']
- [blocks_throttle_0_0_0_0_0_0_0_0, '0', blocks_packed_to_unpacked_xx_0_0_0_0_0_0_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', beamforming_phasedarray_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', beamforming_phasedarray_0_0, '0']
- [digital_chunks_to_symbols_xx_0_0_0, '0', beamforming_phasedarray_0_0_0, '0']
- [digital_chunks_to_symbols_xx_0_0_0_0, '0', beamforming_phasedarray_0_0_0_0, '0']
- [digital_chunks_to_symbols_xx_0_0_0_0_0, '0', beamforming_phasedarray_0_0_0_0_0, '0']
- [digital_chunks_to_symbols_xx_0_0_0_0_0_0, '0', beamforming_phasedarray_0_0_0_0_0_0, '0']
- [digital_chunks_to_symbols_xx_0_0_0_0_0_0_0, '0', beamforming_phasedarray_0_0_0_0_0_0_0, '0']
- [digital_chunks_to_symbols_xx_0_0_0_0_0_0_0_0, '0', beamforming_phasedarray_0_0_0_0_0_0_0_0, '0']
- [virtual_source_0, '0', blocks_add_xx_0, '0']
- [virtual_source_0_0, '0', blocks_add_xx_0_1, '0']
- [virtual_source_0_0_0, '0', blocks_add_xx_0_1_0, '0']
- [virtual_source_0_1, '0', blocks_add_xx_0_0, '0']
- [virtual_source_0_1_0, '0', blocks_add_xx_0_0_0, '0']
- [virtual_source_0_1_0_0, '0', blocks_add_xx_0_0_0_0, '0']
- [virtual_source_0_1_1, '0', blocks_add_xx_0_0_1, '0']
- [virtual_source_0_2, '0', blocks_add_xx_0_2, '0']

metadata:
  file_format: 1
