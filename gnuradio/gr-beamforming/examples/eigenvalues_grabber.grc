options:
  parameters:
    author: grigosback
    generate_options: no_gui
    id: eigenvalues_grabber
    output_language: python
    title: Eigenvalues Grabber
  states: {}

blocks:
- name: bps_1
  id: variable
  parameters:
    value: const_1.bits_per_symbol()
  states: {}
- name: bps_2
  id: variable
  parameters:
    value: const_2.bits_per_symbol()
  states: {}
- name: const_1
  id: variable_constellation
  parameters:
    precision: '8'
    type: 8psk
  states: {}
- name: const_2
  id: variable_constellation
  parameters:
    precision: '8'
    type: 16qam
  states: {}
- name: fc
  id: variable
  parameters:
    value: 436e6
  states: {}
- name: mx
  id: variable
  parameters:
    value: '4'
  states: {}
- name: my
  id: variable
  parameters:
    value: '4'
  states: {}
- name: n
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '150000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '10000'
    repeat: 'False'
    type: byte
  states: {}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '10000'
    repeat: 'False'
    type: byte
  states: {}
- name: analog_vectornoise_source_0
  id: analog_vectornoise_source
  parameters:
    ampl: noise_voltage_1
    vlen: mx*my
  states: {}
- name: analog_vectornoise_source_0_0
  id: analog_vectornoise_source
  parameters:
    ampl: noise_voltage_2
    vlen: mx*my
  states: {}
- name: beamforming_doaesprit_py_cf_0
  id: beamforming_doaesprit_py_cf
  parameters:
    element_separation: (299792458/(2*fc))
    fc: fc
    file_name: file_name
    mx: mx
    my: my
    n: n
    spd: '128'
  states: {}
- name: beamforming_phasedarray_0
  id: beamforming_phasedarray
  parameters:
    element_error: element_separation
    element_separation: (299792458/(2*fc))
    fc: 436e6
    mx: mx
    my: my
    phi: phi_1
    theta: theta_1
  states: {}
- name: beamforming_phasedarray_0_0
  id: beamforming_phasedarray
  parameters:
    element_error: element_separation
    element_separation: (299792458/(2*fc))
    fc: 436e6
    mx: mx
    my: my
    phi: phi_2
    theta: theta_2
  states: {}
- name: beamforming_randomsampler_0
  id: beamforming_randomsampler
  parameters:
    decimation: '8'
    vlen: mx*my
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
    vlen: mx*my
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
    vlen: mx*my
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
    vlen: mx*my
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: bps_1
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_0_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: bps_2
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: const_1_name
  id: parameter
  parameters:
    type: str
    value: '"BPSK"'
  states: {}
- name: const_2_name
  id: parameter
  parameters:
    type: str
    value: '"QPSK"'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: const_1.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: const_2.points()
  states: {}
- name: element_separation
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: file_name
  id: parameter
  parameters:
    type: str
    value: '"eigenvalues5.csv"'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import random
  states: {}
- name: noise_voltage_1
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: noise_voltage_2
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: phi_1
  id: parameter
  parameters:
    label: Azimut Angle 1
    type: eng_float
    value: '70'
  states: {}
- name: phi_2
  id: parameter
  parameters:
    label: Azimut Angle 2
    type: eng_float
    value: '41'
  states: {}
- name: theta_1
  id: parameter
  parameters:
    label: Elevation Angle 1
    type: eng_float
    value: '45'
  states: {}
- name: theta_2
  id: parameter
  parameters:
    label: Elevation Angle 1
    type: eng_float
    value: '75'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: channel_1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: samples
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: channel_2
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: channel_1
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: channel_2
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [analog_random_source_x_0_0, '0', blocks_throttle_0_0, '0']
- [analog_vectornoise_source_0, '0', blocks_add_xx_0, '1']
- [analog_vectornoise_source_0_0, '0', blocks_add_xx_0_0, '1']
- [beamforming_phasedarray_0, '0', virtual_sink_0, '0']
- [beamforming_phasedarray_0_0, '0', virtual_sink_0_1, '0']
- [beamforming_randomsampler_0, '0', beamforming_doaesprit_py_cf_0, '0']
- [blocks_add_xx_0, '0', blocks_add_xx_1, '0']
- [blocks_add_xx_0_0, '0', blocks_add_xx_1, '1']
- [blocks_add_xx_1, '0', beamforming_randomsampler_0, '0']
- [blocks_add_xx_1, '0', virtual_sink_0_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_packed_to_unpacked_xx_0_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [blocks_throttle_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_throttle_0_0, '0', blocks_packed_to_unpacked_xx_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', beamforming_phasedarray_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', beamforming_phasedarray_0_0, '0']
- [virtual_source_0, '0', blocks_add_xx_0, '0']
- [virtual_source_0_1, '0', blocks_add_xx_0_0, '0']

metadata:
  file_format: 1
