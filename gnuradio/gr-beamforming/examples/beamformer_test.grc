options:
  parameters:
    author: grigosback
    generate_options: qt_gui
    id: beamformer_test
    output_language: python
    title: Beamformer - TEst
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: beamforming_beamformer_0
  id: beamforming_beamformer
  parameters:
    mx: '4'
    my: '4'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.to_pmt("doa"),pmt.list2(pmt.from_long(123),pmt.from_long(234)))
    period: '1000'
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
    vlen: '16'
  states: {}
- name: blocks_vector_sink_x_0
  id: blocks_vector_sink_x
  parameters:
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: ([1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1])
    vlen: '16'
  states: {}
- name: zeromq_req_msg_source_0
  id: zeromq_req_msg_source
  parameters:
    address: tcp://127.0.0.1:5557
    timeout: '100'
  states: {}

connections:
- [beamforming_beamformer_0, '0', blocks_vector_sink_x_0, '0']
- [blocks_message_strobe_0, strobe, beamforming_beamformer_0, doa_port]
- [blocks_throttle_0, '0', beamforming_beamformer_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']
- [zeromq_req_msg_source_0, out, beamforming_beamformer_0, doa_port]
- [zeromq_req_msg_source_0, out, blocks_message_debug_0, print]

metadata:
  file_format: 1
